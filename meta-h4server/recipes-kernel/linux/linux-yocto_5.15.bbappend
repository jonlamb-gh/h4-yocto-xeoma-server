FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}-5.15:"
SRC_URI += "file://iptables.cfg"
